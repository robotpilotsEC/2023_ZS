# Keil uVision project CAN_Motor.uvprojx, settings and files
target CAN_Motor (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Infantry_2022 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx ,USE_STDPERIPH_DRIVER,__FPU_PRESENT = 1U,ARM_MATH_CM4,__CC_ARM,__TARGET_FPU_VFP,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../application;../boards;../application_driver;../application/application_device;../application/application_potocal;./USER/POTOCAL.h;./USER/rp_math.h;./USER/imu;../application/Can;../application/application_driver;./USER/DSP;./USER/Driver;./USER/Function;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../device;../application/application_Module;./USER/Algo;../application/application_task;../application/application_config;../application/application_function
  asm include: ..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Config
    ../application/application_config/: motor_config.h speed_config.h zs_rp_config.h
  group Application/User/Core
    ../: README.txt
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group application/Alog2
    ../application/: pid.c
    ../application/Can/: CAN_receive.c CAN_send.c
  group application/Driver
    ../application/application_driver/: uart_drv.c haltick_drv.c drv_io.c tim_drv.c
  group application/Device
    ../application/application_device/: rc.c imu.c gimbal_motor.c classis_motor.c shoot_motor.c vision_potocal.c vision_sensor.c judge_sensor.c judge_infantryprotocol.c slave.c super_cap.c
    ./USER/Function/: Power_Limit.c
  group application/Potocal
    ../application/application_device/: Motor.c
    ../application/application_potocal/: usart_potocal.c imu_polotal.c can_protocal.c Cap_protocal.c
  group application/Algo1
    ./USER/rp_math.h/: rp_math.c
    ./USER/Algo/: crc.c
  group application/Device_BMI
    ../application/application_device_BMI/: bmi.c bmi2.c bmi2_common.c bmi2_ois.c bmi270.c bmi270_context.c
  group application_Function
    ./USER/Function/: S_function.c UI.c
    ./USER/Driver/: soft_iic.c
  group application_Module
    ../application/application_Module/: Offline_check.c Chassis.c key.c Gimbal.c Shoot.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application/Task
    ../application/application_task/: Classis_task.c Gimbal_task.c Judge_task.c Shoot_task.c Vision_task.c Rc_task.c Imu_task.c Normal_task.c
  group Application/Config
    ../application/application_config/: rp_init.c
  group Application/Function
    ../application/application_function/: Auto_Aim.c
  group DSP
    ./USER/DSP/: arm_cortexM4lf_math.lib arm_math.h
    ./USER/DSP/Include/: arm_common_tables.h arm_const_structs.h arm_math.h core_sc000.h core_sc300.h
software components: CMSIS:CORE 4.3.0
